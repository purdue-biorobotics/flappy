Commit message: fix visulization, restructure folder, PID and ARC working

File: flappy/urdf/ground.urdf (robot description, URDF)
Before this commit: robot ground_skeleton, 2 links, 1 joints
Joints:
- joint ground_joint: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 0 -0.2 rpy=0 0 0
